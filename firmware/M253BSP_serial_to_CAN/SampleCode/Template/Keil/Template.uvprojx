# Keil uVision project Template.uvprojx, settings and files
target Template (6220000::V6.22::ARMCLANG)
  device: M253LE3AE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.1
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: Template +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=3 v6LangP=1
  c include: ..\..\..\Library\CMSIS\Core\Include;..\..\..\Library\StdDriver\inc;..\..\..\Library\Device\Nuvoton\M251\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\..\..\Library\Device\Nuvoton\M253\Source\ARM\APROM.sct
  group CMSIS
    ../../../Library/Device/Nuvoton/M253/Source/: system_M253.c
    ../../../Library/Device/Nuvoton/M253/Source/ARM/: startup_M253.c
  group Library
    ../../../Library/StdDriver/src/: retarget.c uart.c sys.c clk.c timer.c canfd.c
  group User
    ../: main.c bridge_host_link.c bridge_hw_abstraction.c bridge_nuvoisp_can.c misc_config.c
