# Keil uVision project Template.uvprojx, settings and files
target Template (6220000::V6.22::ARMCLANG)
  device: M2A23SG5AC Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.1
  cpu: IRAM(0x20000000,0x6000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: Template +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=3 v6LangP=1
  c include: ..\..\..\Library\Device\Nuvoton\m2a23\Include;..\..\..\Library\StdDriver\inc;..\..\..\Library\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  link misc: --map --first='startup_m2a23.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/m2a23/Source/ARM/: startup_m2a23.S
    ../../../Library/Device/Nuvoton/m2a23/Source/: system_m2a23.c
  group Library
    ../../../Library/StdDriver/src/: clk.c sys.c retarget.c uart.c timer.c canfd.c
  group User
    ../: main.c bridge_host_link.c bridge_hw_abstraction.c bridge_nuvoisp_can.c misc_config.c
