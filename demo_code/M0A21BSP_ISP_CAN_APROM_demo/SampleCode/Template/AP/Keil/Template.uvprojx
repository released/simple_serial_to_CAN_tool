# Keil uVision project Template.uvprojx, settings and files
target Template (6220000::V6.22::ARMCLANG)
  device: M0A23EC1AC Nuvoton
  pack: Nuvoton.NuMicroM0_DFP.1.0.2
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: APROM_application +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: generateChecksum.bat
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=1 v6Lto=1
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M0A21\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\Template
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M0A21.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M0A21/Source/: system_M0A21.c
    ../../../../Library/Device/Nuvoton/M0A21/Source/ARM/: startup_M0A21.s
  group Library
    ../../../../Library/StdDriver/src/: retarget.c uart.c clk.c sys.c timer.c gpio.c
  group User
    ../: main.c misc_config.c
