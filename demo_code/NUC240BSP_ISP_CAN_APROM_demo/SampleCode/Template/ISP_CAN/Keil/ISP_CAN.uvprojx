# Keil uVision project ISP_CAN.uvprojx, settings and files
target ISP_CAN (6120000::V6.12::.\ARMCLANG)
  device: NUC240VE3AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.5
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: LDROM_Bootloader
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC230_240\Include;..\..\..\..\Library\StdDriver\inc;..\..\ISP_CAN;..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC230_240.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC230_240/Source/: system_NUC230_240.c
    ../../../../Library/Device/Nuvoton/NUC230_240/Source/ARM/: startup_NUC230_240.s
  group Library
    ../../../../Library/StdDriver/src/: can.c fmc.c clk.c
  group User
    ../: main.c
