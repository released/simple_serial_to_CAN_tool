# Keil uVision project Template.uvprojx, settings and files
target Template (6220000::V6.22::ARMCLANG)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicroM4_DFP.1.0.0
  cpu: IRAM(0x20000000,0x80000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: APROM_application +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\m460\Include;..\..\..\Library\StdDriver\inc;..\..\Template
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --map --first='startup_m460.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/m460/Source/: system_m460.c
    ../../../Library/Device/Nuvoton/m460/Source/ARM/: startup_m460.S
  group Library
    ../../../Library/StdDriver/src/: retarget.c uart.c sys.c clk.c gpio.c timer.c
  group User
    ../: main.c misc_config.c
target sram (6220000::V6.22::ARMCLANG)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicroM4_DFP.1.0.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x9FFF) CLOCK(72000000) CPUTYPE("Cortex-M4") FPU2
  output: APROM_application
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: generateChecksum.bat
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: _PZ=1
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\m460\Include;..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xa000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: as above
